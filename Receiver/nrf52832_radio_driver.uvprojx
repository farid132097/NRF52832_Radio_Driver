# Keil uVision project nrf52832_radio_driver.uvprojx, settings and files
target NRF52832 (6160000::V6.16::ARMCLANG)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: nrf52832_radio_driver
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x800000 size 0x10000
  group inc
    ./: cdefs.h app.h timeout.h radio.h uart.h clocks.h led.h pwm.h datahandler.h config.h rtc.h arq.h
  group src
    ./: app.c main.c timeout.c radio.c uart.c clocks.c led.c pwm.c datahandler.c rtc.c arq.c
software components: CMSIS:CORE 6.1.0, Device:Startup 8.44.1
